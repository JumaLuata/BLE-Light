# IAR project proximity_reporter_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw41z/wireless_examples/bluetooth/proximity_reporter/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_9.0.0/Source/include; ..; ../../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.4/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.4/GPIO; ../../../../../../../middleware/wireless/framework_5.3.4/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/Common; ../../../../../../../middleware/wireless/framework_5.3.4/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.4/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.4/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.4/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.4/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.4/Lists; ../../../../../../../middleware/wireless/framework_5.3.4/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.4/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.4/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.4/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.4/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/proximity; ../../../../../../../middleware/wireless/framework_5.3.4/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.4/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.4/XCVR/MKW41Z4; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: proximity_reporter_frdmkw41z.bin
  ILINK.IlinkOutputFile: proximity_reporter_freertos.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.4/host/lib/lib_ble_4-2_host_peripheral_cm0p.a; ../../../../../../../middleware/wireless/bluetooth_1.2.4/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.4/SecLib/lib_crypto_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/host/config/: ble_config.h ble_globals.c
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/battery/: battery_interface.h battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/device_info/: device_info_interface.h device_info_service.c
  group bluetooth/profiles/proximity
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/profiles/proximity/: immediate_alert_interface.h immediate_alert_service.c link_loss_interface.h link_loss_service.c tx_power_interface.h tx_power_service.c
  group board
    ../: board.c board.h clock_config.c clock_config.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_ltc.c fsl_ltc.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_trng.c fsl_trng.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.4/Common/: EmbeddedTypes.h
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/DCDC/Source/: DCDC.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.4/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.4/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.4/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.4/ModuleInfo/: ModuleInfo.c ModuleInfo.h
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/MWSCoexistence/Source/: MWS.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/OSAbstraction
    ../../../../../../../middleware/wireless/framework_5.3.4/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
    ../../../../../../../middleware/wireless/framework_5.3.4/OSAbstraction/Interface/: fsl_os_abstraction_free_rtos.h
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.4/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/SerialManager/Source/: SerialManager.c UART_Adapter.c UART_Adapter.h
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.4/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.4/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.4/XCVR/MKW41Z4/: dbg_ram_capture.c dbg_ram_capture.h fsl_xcvr.c fsl_xcvr.h fsl_xcvr_trim.c fsl_xcvr_trim.h ifr_radio.c ifr_radio.h
    ../../../../../../../middleware/wireless/framework_5.3.4/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ant_config.c fsl_xcvr_ble_config.c fsl_xcvr_common_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_msk_config.c fsl_xcvr_zgbe_config.c
  group freertos
    ../../../../../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group source
    ../../: app_config.c gatt_db.h gatt_uuid128.h hid_interface.h hid_service.c proximity_reporter.c proximity_reporter.h
    ../: app_preinclude.h FreeRTOSConfig.h
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common/: ApplMain.c ApplMain.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h ieee11073.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.4/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
